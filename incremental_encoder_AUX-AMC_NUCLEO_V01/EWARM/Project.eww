<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_AUX-AMC_NUCLEO_V02.ewp</path>
  </project>
  <batchBuild />
</workspace>
